PACKAGECONFIG_DISTRO_append = " accessibility fontconfig tslib"
