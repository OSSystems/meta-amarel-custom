FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Enable-share-group-workaround-for-Vivante-GPUs.patch"
