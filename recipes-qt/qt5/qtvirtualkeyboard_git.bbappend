PACKAGECONFIG = "lipi-toolkit lang-en_GB lang-es_ES lang-pt_PT lang-zh_CN lang-fr_FR lang-it_IT"
