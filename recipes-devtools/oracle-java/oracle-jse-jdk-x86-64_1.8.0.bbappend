RDEPENDS_${PN}_remove = "libasound atk cairo gdk-pixbuf mesa gtk+ libxtst libxi"
