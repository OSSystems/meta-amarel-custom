# Automatically choose java package based on target architecture

require oracle-jse-ejre-arm-vfp-hflt-client-headless.inc
