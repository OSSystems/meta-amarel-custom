
EXTRA_OECONF = "--with-security-framework=dummy \
                 --disable-qt \
                 --disable-gstreamer-plugin \
                 --disable-local  \
                 --enable-networkmanager \
                 --disable-device-rebind \
                 ac_cv_path_XMLTO=no \
"

